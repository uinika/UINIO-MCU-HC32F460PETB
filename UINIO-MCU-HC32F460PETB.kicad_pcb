# Repository uinika/UINIO-MCU-HC32F460PETB

File README.md:

# UINIO-MCU-HC32F460PETB 核心板

[**UINIO-MCU-HC32F460PETB**](https://gitee.com/uinika/UINIO-MCU-HC32F460PETB) 是一款基于小华半导体 **HC32F460PETB-LQFP100** 型微控制器的核心板，该款微控制器的最大特点是支持 `1.8V ~ 3.6V` 的**宽电压范围**，和 `-40℃ ~ 105℃` 的**宽温度范围**。基于 **ARM Cortex-M4** 内核架构，最高工作频率可以达到 `200MHz`，内置有 **DSP** 数字信号处理器和 **FPU** 浮点运算单元。除此之外，还集成有 `512KB` 的 Flash 存储器，以及 `192KB` 的 SRAM 存储器。

## 设计概要

- 外部晶振电路，全部使用了打孔包地处理；
- 扩展了两路串联有自恢复保险丝的 `5V` 电源接口，整体采用覆铜处理，以提升接口的载流能力；
- 模拟电源引脚 `AVSS` 和 `AVCC` 都串联有对 `100Mhz` 高频杂散信号存在 `1KΩ` 阻抗的磁珠；
- 对调试下载接口 SWD 进行了前置处理，并且匹配了通信线序，可以方便快速的与 [**UINIO-DAPLink**](https://gitee.com/uinika/UINIO-DAPLink) 进行杜邦线连接；
- 引出了全部的 **83** 个 GPIO 端口，可以自由的使用 **8** 种常见的外设通信接口：

| 接口名称       | 数量  | 描述                                                                        |
| :------------- | :---- | :-------------------------------------------------------------------------- |
| **GPIO**       | 83 个 | `PAx`、`PBx`、`PCx`、`PDx`、`PEx`、`PHx` 一共六组。                         |
| **I2C**        | 3 组  | 支持 SMBus 协议。                                                           |
| **USART**      | 4 组  | 支持 ISO7816-3 协议。                                                       |
| **SPI**        | 4 组  | 支持 4 线式 SPI 模式和 3 线式时钟同步模式，支持全双工和只传送两种通信方式。 |
| **QSPI**       | 1 组  | 支持 `200Mbps` 高速访问的存储器控制模块。                                   |
| **I2S**        | 4 组  | 内置音频 PLL 支持音频级采样精度。                                           |
| **SDIO**       | 2 组  | 支持 SD/MMC/eMMC 格式。                                                     |
| **CAN**        | 1 组  | 支持 ISO11898-1 标准协议。                                                  |
| **USB 2.0 FS** | 1 组  | 内置 PHY，支持 Device/Host 模式。                                           |

## 参考技术文档

[UinIO.com 电子技术实验室](http://uinio.com/) 为 **UINIO-MCU-HC32F460PETB** 开源项目提供了如下一系列参考技术资料：

- [《UINIO-MCU-HC32F460PETB 核心板原理图》](http://uinio.com/my/works/UINIO-MCU-HC32F460PETB/UINIO-MCU-HC32F460PETB-Schematic.pdf)
- [《交互式 BOM 物料清单与 PCB 版图在线预览》](http://uinio.com/my/works/UINIO-MCU-HC32F460PETB/UINIO-MCU-HC32F460PETB-BOM.html)

## KiCad design UINIO-MCU-HC32F460PETB.kicad_pcb

Parts:
C1, C5, C8, C9, C10, C12, C13, C17, C19, C20, C21, C22, C23: 0.1uF; C_0603_1608Metric
C2, C3, C4, C7, C11, C24: 1uF; C_0603_1608Metric
C6: 4.7uF; C_0603_1608Metric
C14, C15, C16, C18: 10pF; C_0603_1608Metric
D1: LED-RED; LED_0603_1608Metric
F1: Fuse; Fuse_1206_3216Metric
J1: Conn_01x18_Pin; PinHeader_1x18_P2.54mm_Vertical
J2, J3: Conn_01x34_Pin; PinHeader_1x34_P2.54mm_Vertical
J4: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J5, J6, J7, J8, J9: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
L1, L2, L3, L4: 1K 100MHz; L_0603_1608Metric
R1, R2: 5.1K; R_0603_1608Metric
R3: 2K; R_0603_1608Metric
R4: 4.7K; R_0603_1608Metric
R5, R6, R7: 10K; R_0603_1608Metric
SW1: NRST; SW-SMD_4P-L4.2-W3.4-P2.15-LS4.7
U1: ME6211C33M5G; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BL
U2: HC32F460PETB-LQFP100; LQFP-100_L14.0-W14.0-P0.50-LS16.0-BL
USB1: USB_Type_C_16Pin
Y1: 32.768KHz; Crystal_SMD_3215-2Pin_3.2x1.5mm
Y2: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/AVCC: J1.4, J3.32, L2.2, U2.22 (AVCC), U2.28 (AVCC)
/AVSS: J3.33, L1.2, U2.27 (AVSS)
/AVSS/VREFL: J1.6, L3.2, U2.20 (AVSS/VREFL)
/NRST: C13.2, J1.11, R5.1, SW1.1, SW1.2, U2.14 (NRST)
/PA0: J1.3, U2.23 (PA0/ADC1_IN0)
/PA1: J1.2, U2.24 (PA1/ADC1_IN1)
/PA2: J1.1, U2.25 (PA2/ADC1_IN2)
/PA3: J3.34, U2.26 (PA3/ADC1_IN3)
/PA4: J3.31, U2.29 (PA4/ADC12_IN4)
/PA5: J3.30, U2.30 (PA5/ADC12_IN5)
/PA6: J3.29, U2.31 (PA6/ADC12_IN6)
/PA7: J3.28, U2.32 (PA7/ADC12_IN7)
/PA8: J2.5, U2.67 (PA8)
/PA9: J2.6, U2.68 (PA9/USBFS_VBUS)
/PA10: J2.7, U2.69 (PA10/USBFS_ID)
/PA11: J2.8, U2.70 (PA11/USBFS_DM)
/PA12: J2.9, U2.71 (PA12/USBFS_DP)
/PA13/JTMS_SWDIO: J2.10, J7.4, R7.1, U2.72 (PA13/JTMS_SWDIO)
/PA14/JTCK_SWCLK: J2.11, J7.3, R6.2, U2.76 (PA14/JTCK_SWCLK)
/PA15: J2.12, U2.77 (PA15/JTDI)
/PB0: J3.25, U2.35 (PB0/ADC12_IN8)
/PB1: J3.24, U2.36 (PB1/ADC12_IN9)
/PB2: J3.23, U2.37 (PB2/PVD2EXINP)
/PB3: J2.24, U2.89 (PB3/JTDO_TRACESWO)
/PB4: J2.25, U2.90 (PB4/NJTRST)
/PB5: J2.26, U2.91 (PB5)
/PB6: J2.27, U2.92 (PB6)
/PB7: J2.28, U2.93 (PB7)
/PB8: J2.29, U2.95 (PB8)
/PB9: J2.30, U2.96 (PB9)
/PB10: J3.13, U2.47 (PB10)
/PB11/MD: C9.2, J4.1, R4.1, U2.94 (PB11/MD)
/PB12: J3.12, U2.51 (PB12)
/PB13: J3.11, U2.52 (PB13)
/PB14: J3.10, U2.53 (PB14)
/PB15: J3.9, U2.54 (PB15)
/PC0: J1.10, U2.15 (PC0/ADC12_IN10)
/PC1: J1.9, U2.16 (PC1/ADC12_IN11)
/PC2: J1.8, U2.17 (PC2/ADC1_IN12)
/PC3: J1.7, U2.18 (PC3/ADC1_IN13)
/PC4: J3.27, U2.33 (PC4/ADC1_IN14)
/PC5: J3.26, U2.34 (PC5/ADC1_IN15)
/PC6: J2.1, U2.63 (PC6)
/PC7: J2.2, U2.64 (PC7)
/PC8: J2.3, U2.65 (PC8)
/PC9: J2.4, U2.66 (PC9)
/PC10: J2.13, U2.78 (PC10)
/PC11: J2.14, U2.79 (PC11)
/PC12: J2.15, U2.80 (PC12)
/PC13: J1.12, U2.7 (PC13)
/PD0: J2.16, U2.81 (PD0)
/PD1: J2.17, U2.82 (PD1)
/PD2: J2.18, U2.83 (PD2)
/PD3: J2.19, U2.84 (PD3)
/PD4: J2.20, U2.85 (PD4)
/PD5: J2.21, U2.86 (PD5)
/PD6: J2.22, U2.87 (PD6)
/PD7: J2.23, U2.88 (PD7)
/PD8: J3.8, U2.55 (PD8)
/PD9: J3.7, U2.56 (PD9)
/PD10: J3.6, U2.57 (PD10)
/PD11: J3.5, U2.58 (PD11)
/PD12: J3.4, U2.59 (PD12)
/PD13: J3.3, U2.60 (PD13)
/PD14: J3.2, U2.61 (PD14)
/PD15: J3.1, U2.62 (PD15)
/PE0: J2.31, U2.97 (PE0)
/PE1: J2.32, U2.98 (PE1)
/PE2: J1.18, U2.1 (PE2)
/PE3: J1.17, U2.2 (PE3)
/PE4: J1.16, U2.3 (PE4)
/PE5: J1.15, U2.4 (PE5)
/PE6: J1.14, U2.5 (PE6)
/PE7: J3.22, U2.38 (PE7)
/PE8: J3.21, U2.39 (PE8)
/PE9: J3.20, U2.40 (PE9)
/PE10: J3.19, U2.41 (PE10)
/PE11: J3.18, U2.42 (PE11)
/PE12: J3.17, U2.43 (PE12)
/PE13: J3.16, U2.44 (PE13)
/PE14: J3.15, U2.45 (PE14)
/PE15: J3.14, U2.46 (PE15)
/PH2: J1.13, U2.6 (PH2)
/VREFH: J1.5, L4.2, U2.21 (VREFH)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, D1.1 (K), J2.34, J4.2, J4.3, J6.1, J6.2, J6.3, J6.4, J7.2, J9.1, J9.2, J9.3, J9.4, L1.1, L3.1, R1.2, R2.2, SW1.3, SW1.4, U1.2 (VSS), U2.10 (VSS), U2.49 (VSS), U2.74 (VSS), U2.99 (VSS), USB1.13 (GND), USB1.14 (GND), USB1.15 (GND), USB1.16 (GND), USB1.A1B12 (GND), USB1.B1A12 (GND)
unnamed: C14.2, Y2.4
unnamed: C18.2, Y2.2
unnamed: D1.2 (A), R3.1
unnamed: F1.1, J5.1, J5.2, J5.3, J5.4
unnamed: C15.2, U2.8 (PC14/XTAL32_OUT), Y1.2
unnamed: C16.2, U2.9 (PC15/XTAL32_IN), Y1.1
unnamed: U2.12 (PH0/XTAL_IN), Y2.3
unnamed: U2.13 (PH1/XTAL_OUT), Y2.1
unnamed: C12.2, U2.48 (VCAP_1)
unnamed: C22.2, U2.73 (VCAP_2)
unnamed: R1.1, USB1.A5 (CC1)
unnamed: R2.1, USB1.B5 (CC2)
VCC_3.3V: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C17.2, C19.2, C20.2, C21.2, C23.2, C24.2, J2.33, J7.1, J8.1, J8.2, J8.3, J8.4, L2.1, L4.1, R3.2, R4.2, R5.2, R6.1, R7.2, U1.5 (VOUT), U2.11 (VCC), U2.19 (VCC), U2.50 (VCC), U2.75 (VCC), U2.100 (VCC)
VCC_5V: C4.2, C10.2, C11.2, F1.2, U1.1 (VIN), U1.3 (CE), USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)

Notes on the sheet:
SWD 调 试 接 口
3.3V 线性稳压电路
38Pin 2.54mm 杜邦排针
HC32F460PETB-LQFP100 最小系统
USB Type-C 接口电路
3.3V & 5V 输出接口

Board: 2 copper layers, 93.7 x 53.1 mm, 56 parts (0 on the bottom side), 99 nets.

Other parts of the board:
HOLE**: Hole-2mm
HOLE**#2, HOLE**#3, HOLE**#4: Hole-2mm

## Commit log

2024-08-12 Update schematic.
2024-12-07 Release UINIO-MCU-HC32F460PETB version 1.0.0.
